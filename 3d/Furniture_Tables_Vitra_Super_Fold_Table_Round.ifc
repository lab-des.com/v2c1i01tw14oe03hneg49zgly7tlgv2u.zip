Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-24T14:26:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 24 14:26:53 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{58788738-E159-4D59-9F5A-BF672EAE9B79}\ifc * Database version: 5507 * Database creation date: Wed Jun 24 14:26:51 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 24 14:26:52 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 24 14:26:52 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Super Fold Table, Round, Furniture_Tables_Vitra_Super_Fold_Table_Round:Super Fold Table, Round:375325
In: Level 1
Type - Material: 30 Basic Dark, Light oak veneer
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Tables_Vitra_Super_Fold_Table_Round; ConvergoRefNr: 0089-2006-0025-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: The Super Fold Table by Jasper Morrison folds up completely with a single movement of the hand, and the legs of the four-star base are also rotated and vertically aligned for compact space-saving storage.; Revision: n/a; Uniclass2: Pr_40_50_21_58; Uniclass2015Description: Occasional tables; Uniclass2015Reference: Pr_40_50_21_58; Version: 1; VersionDate: 23/06/2020
Type - Identity Data(Type) - Cost: 0; Description: The Super Fold Table by Jasper Morrison folds up completely with a single movement of the hand, and the legs of the four-star base are also rotated and vertically aligned for compact space-saving storage.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: Super Fold Table, Round; OmniClass Number: 23.40.20.14.17.24; OmniClass Title: Coffee Tables; Type Name: Super Fold Table, Round; URL: https://www.vitra.com/en-un/office/product/details/super-fold-table-indoor
Type - Materials and Finishes(Type) - TableSecondaryMaterial: 30 Basic Dark
Type - Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Wooden; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Tables_Vitra_Super_Fold_Table_Round; Features: It is available in both sitting and standing height versions.; Finish: Melamine faced in white with smooth straight plastic edge (19 mm), oak veneer (Europe) in natural or dark oak (19 mm) or solid core material with black edge (12 mm) in the colours white or black. Solid core table top in black with anti-fingerprint coating; Grade: n/a; Material: Wood, metal and plastic; ModelNumber: n/a; ModelReference: n/a; Name: Super_Fold_Table_Round; ReplacementCost: n/a; Shape: Sculptured; Size: 796 x 796 x 740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - TablePosition: Super Fold Table Round Extended
Dimensions - Area: 1.81177 m2; Volume: 0.468905 m3
Materials and Finishes - TableMainMaterial: Light oak veneer
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Tables_Vitra_Super_Fold_Table_Round: Super Fold Table, Round; Family and Type: Furniture_Tables_Vitra_Super_Fold_Table_Round: Super Fold Table, Round; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Tables_Vitra_Super_Fold_Table_Round: Super Fold Table, Round; Type Id: Furniture_Tables_Vitra_Super_Fold_Table_Round: Super Fold Table, Round; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
